# Repository OpenMusicKontrollers/chimaera_dsp_unit

File README.md:

# Chimaera DSP Unit

## About
This is the PCB design for the DSP unit of the [Chimaera](http://open-music-kontrollers.ch/chimaera/) - a poly-magneto-phonic theremin.

## Prerequisites
To be used with [KiCAD](http://www.kicad-pcb.org).

## License
This is open source hardware and licensed under [CERN OHL v.1.2](http://ohwr.org/cernohl).

## KiCad design chimaera_dsp_unit.kicad_pcb

Parts:
C1, C9: 18pF; Digi-Key 311-1061-1-ND
C2, C3, C4, C21, C22, C23: 0.1uF; Digi-Key 445-1314-1-ND
C5: 4.7uF; Digi-Key 445-6859-1-ND
C6: 10nF; Digi-Key 311-1572-1-ND
C7: 1uF; Digi-Key 445-1358-1-ND
C8: 10uF; Digi-Key 478-3273-1-ND
C10: 10uF; Digi-Key 445-6857-1-ND
C16: 33uF; Digi-Key 478-1688-1-ND
D1, D2: DIODE; Digi-Key 568-6512-1-ND
D3: LED; Digi-Key L71504CT-ND
F1: FUSE; Digi-Key F2112CT-ND
FB1: FERR; Digi-Key 240-2578-1-ND
J1: USB_MINI; Digi-Key WM17121-ND
P1: power in; Digi-Key CP-5-ND
P2, P3: from sensor units
P5: to sensor units; Digi-Key S5479-ND
P11: CONN_6
P12: CONN_2
R1, R2, R4: 1k; Digi-Key P1.0KGCT-ND
R3, R5: 10k; Digi-Key P10KGCT-ND
R6, R7: 4.75k; Digi-Key P4.75KHCT-ND
R8: 1.5k; Digi-Key P1.50KHCT-ND
SW1: DPDT; Digi-Key EG4606-ND
U1: LM1117; Digi-Key LM1117MPX-3.3/NOPBCT-ND
U2: MCP1703; Digi-Key MCP1703T-3302E/CBCT-ND
U4: STM32F303CX; MODULE; Digi-Key 497-13318-ND
U5: 24LC64; MODULE; Digi-Key 24LC64-I/SN-ND
U6: 74HC163; Digi-Key 296-33034-5-ND
U7: 24AA025E48; MODULE; Digi-Key 24AA025E48-I/SN-ND
U8: NUF2042; MODULE; Digi-Key NUF2042XV6T1GOSCT-ND
X1: 8MHz; Digi-Key 887-1452-1-ND

Connections:
+3.3V: C2.1, C3.1, C4.1, C5.1, C8.1, C21.2, C22.2, C23.2, R3.1, R4.2, R6.2, R7.2, R8.1, U1.2 (VO), U4.1, U4.24, U4.36, U4.48, U5.8 (vcc), U6.7 (Cep), U6.9 (~Pe), U6.10 (Cet), U6.16 (VCC), U7.1 (a0), U7.8 (vcc); also elsewhere on the board
+3.3VADC: C6.1, C7.1, C10.1, U2.2 (VO), U4.9
+5VD: F1.1, J1.1, U8.5 (VBUS)
+9V: D2.1 (A), P1.1, P2.2, P2.4, P2.6, P2.8, P2.10, P2.12, P2.14, P2.16, P2.18, P2.20
/W5500/MISO: U4.40, U4.42; also elsewhere on the board
/W5500/MOSI: U4.41; also elsewhere on the board
/W5500/SCK: U4.39, U4.43; also elsewhere on the board
/W5500/nINT: U4.37; also elsewhere on the board
/W5500/nSS: U4.38; also elsewhere on the board
ADC1: P3.1, U4.11
ADC2: P3.2, U4.12
ADC3: P3.3, U4.10
ADC4: P3.4, U4.13
ADC5: P3.5, U4.14
ADC6: P3.6, U4.15
ADC7: P3.7, U4.16
ADC8: P3.8, U4.17
ADC9: P3.9, U4.19
ADC10: P3.10, U4.18
BOOT0: R5.1, SW1.2, U4.29, U4.44
CP: U4.46, U6.2 (Cp)
GND: C1.1, C2.2, C3.2, C4.2, C5.2, C8.2, C9.1, C16.2, C21.1, C22.1, C23.1, FB1.2, J1.4, P1.2 (PM), R1.2, R2.2, R5.2, U1.3 (GND), U4.23, U4.35, U4.47, U5.1 (a0), U5.2 (a1), U5.3 (a2), U5.4 (gnd), U5.7 (wp), U6.3 (P0), U6.4 (P1), U6.5 (P2), U6.6 (P3), U6.8 (GND), U7.2 (a1), U7.3 (a2), U7.4 (gnd), U8.2 (GND), X1.2 (GND), X1.4 (GND); also elsewhere on the board
GNDA: C6.2, C7.2, C10.2, FB1.1, P2.1, P2.3, P2.5, P2.7, P2.9, P2.11, P2.13, P2.15, P2.17, P2.19, U2.3 (GND), U4.8
LED: D3.1 (A), U4.20
MR: U4.45, U6.1 (~MR)
unnamed: D1.1 (A), F1.2
unnamed: P11.1, U4.28
unnamed: P11.2, U4.27
unnamed: P11.3, U4.26
unnamed: P11.4, U4.25
unnamed: P12.2 (PM), U4.21
unnamed: P12.1, U4.22
unnamed: J1.3, U8.4 (D2-O)
unnamed: J1.2, U8.6 (D1-O)
unnamed: C16.1, D1.2 (K), D2.2 (K), U1.1 (VI), U2.1 (VI)
unnamed: D3.2 (K), R1.1
unnamed: R4.1, SW1.1
unnamed: R2.1, SW1.3
OSC_IN: C1.2, U4.5, X1.3
OSC_OUT: C9.2, U4.6, X1.1
RESET: R3.2, SW1.4, U4.7, U4.34; also elsewhere on the board
SCL: P11.5, R6.1, U4.30, U5.6 (scl), U7.6 (scl)
SDA: P11.6, R7.1, U4.31, U5.5 (sda), U7.5 (sda)
USBDM: U4.32, U8.3 (D2-I)
USBDP: R8.2, U4.33, U8.1 (D1-I)
Y0: P5.4, U6.14 (Q0)
Y1: P5.3, U6.13 (Q1)
Y2: P5.2, U6.12 (Q2)
Y3: P5.1, U6.11 (Q3)

Parts:
B51: 120R@100MHz; Digi-Key 240-2383-1-ND
C51, C52: 18pF; Digi-Key 311-1061-1-ND
C53, C61: 10uF; Digi-Key 478-8456-1-ND
C54, C55, C56, C57, C58, C59, C60: 0.1uF; Digi-Key 445-1314-1-ND
C62: 4.7uF; Digi-Key 445-6859-1-ND
C63, C65: 10nF; Digi-Key 311-1572-1-ND
C64: 22nF; Digi-Key 311-1370-1-ND
C66, C67: 6.8nF; Digi-Key 311-1084-1-ND
J51: RJ45-TRANSFO; Digi-Key 380-1106-ND
R51: 1M; Digi-Key P1.00MHCT-ND
R52: 12.4k; Digi-Key P12.4KHCT-ND
R53, R54, R55, R56, R57, R58, R59, R60, R62, R63, R64: 10k; Digi-Key P10KGCT-ND
R61: 10k; Digi-Key P10KGCT-ND
R65, R66: 49.9/1%; Digi-Key P49.9HCT-ND
R67: 10; Digi-Key P10.0HCT-ND
R68, R69: 82/1%; Digi-Key P82.0HCT-ND
R70, R71: 330; Digi-Key P330HCT-ND
U51: W5500; MODULE; Digi-Key 1278-1021-ND
X51: 25MHz; Digi-Key CTX826CT-ND

Connections:
+3.3V: B51.2, C60.2, C61.1, J51.GA (LEDG_A), J51.YA (LEDY_A), R53.1, R54.1, R55.1, R61.1, R63.2, R64.2, U51.28 (VCC3V3); also elsewhere on the board
/W5500/MISO: U51.34 (MISO); also elsewhere on the board
/W5500/MOSI: U51.35 (MOSI); also elsewhere on the board
/W5500/SCK: U51.33 (SCLK); also elsewhere on the board
/W5500/nINT: R63.1, U51.36 (INTn); also elsewhere on the board
/W5500/nSS: R64.1, U51.32 (SCSn); also elsewhere on the board
ACTLED: R70.1, U51.27 (ACTLED)
GND: C51.1, C52.1, C53.2, C54.1, C55.1, C56.1, C57.1, C58.1, C59.1, C60.1, C61.2, C62.2, C63.2, C64.1, C65.2, J51.8, R52.1, R56.1, R57.1, R58.1, R59.1, R60.1, R62.2, U51.3 (GNDA), U51.9 (GNDA), U51.14 (GNDA), U51.16 (GNDA), U51.19 (GNDA), U51.29 (GND), U51.48 (GNDA), X51.2 (GND), X51.4 (GND); also elsewhere on the board
LINKLED: R71.1, U51.25 (LINKLED)
unnamed: R54.2, U51.44 (PMODE1)
unnamed: C63.1, U51.22 (1V2O)
unnamed: C62.1, U51.20 (TOCAP)
unnamed: R59.2, U51.39 (RSVD)
unnamed: R60.2, U51.38 (RSVD)
unnamed: C67.2, J51.6 (RD-)
unnamed: C66.2, J51.4 (RD+)
unnamed: R56.2, U51.42 (RSVD)
unnamed: R62.1, U51.23 (RSVD)
unnamed: R57.2, U51.41 (RSVD)
unnamed: R58.2, U51.40 (RSVD)
unnamed: R52.2, U51.10 (EXRES1)
unnamed: J51.GK (LEDG_K), R70.2
unnamed: R53.2, U51.45 (PMODE0)
unnamed: R55.2, U51.43 (PMODE2)
unnamed: J51.YK (LEDY_K), R71.2
RCT: C65.1, J51.5 (RCT), R68.2, R69.2
RESET: R61.2, U51.37 (RTSn); also elsewhere on the board
RXN: C67.1, R69.1, U51.5 (RXN)
RXP: C66.1, R68.1, U51.6 (RXP)
TCT: C64.2, J51.2 (TCT), R67.1
TXN: J51.3 (TD-), R66.1, U51.1 (TXN)
TXP: J51.1 (TD+), R65.1, U51.2 (TXP)
W3V3A: B51.1, C53.1, C54.2, C55.2, C56.2, C57.2, C58.2, C59.2, R65.2, R66.2, R67.2, U51.4 (VCC3V3A), U51.8 (VCC3V3A), U51.11 (VCC3V3A), U51.15 (VCC3V3A), U51.17 (VCC3V3A), U51.21 (VCC3V3A)
XI: C52.2, R51.2, U51.30 (XI/CLKIN), X51.1
XO: C51.2, R51.1, U51.31 (XO), X51.3

Board: 2 copper layers, 80.0 x 44.0 mm, 88 parts (1 on the bottom side), 76 nets.

Other parts of the board:
G1: OMK_CHIMAERA_INVERTED
G2: OSHW_LOGO
G3: OMK_LOGO

## Commit log

2013-11-25 polished W5500 integration, add AD75019
2013-12-01 bug-fix in DSP with wrongly wired I2C2
2013-12-03 chimaera case: adaptions for board design revision 4
2013-12-06 EDA: all resistors now in 0603 format
2013-12-09 equal length traces for differential ethernet lanes
2013-12-17 AD75019 Rev2. case exploded labels.
2014-01-02 EDA: add missing Digi-Key part numbers
2014-03-02 solder paste clearence for 125um mylar stencils
2014-03-02 add READMe.md and licensing
2014-03-02 path fixes after repo split
2014-04-21 3.3V version of Revision 4
2014-05-13 update 3v3 version

Notices in the files:
chimaera_dsp_unit.kicad_pcb:
Copyright (c) 2014 Hanspeter Portner (dev@open-music-kontrollers.ch)
